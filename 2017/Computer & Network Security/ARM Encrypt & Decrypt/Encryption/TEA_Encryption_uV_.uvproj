# Keil uVision project TEA_Encryption_uV_.uvproj, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARM7 (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI) EBIG
  output: TEA_Encryption_uV_
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  group Source Group 1
    ./: TEA_Encryption_uV_.s
